# Keil uVision project test.uvprojx, settings and files
target IIC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\core;..\lib\inc;..\system
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group lib
    ../lib/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c misc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_rng.c stm32f4xx_iwdg.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group core
    ../core/: startup_stm32f40_41xxx.s
  group system
    ../system/: delay.c led_beep.c key.c led_beep_reg.c time.c usart.c adc.c iwdg.c dma.c DHT11.c IIC.c 24C02.c RTC.c
